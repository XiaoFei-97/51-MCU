# Keil uVision project LCD_1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD_1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\LCD4602显示
  asm include: ..\LCD4602显示
  group Source Group 1
    ./: STARTUP.A51 main.c
